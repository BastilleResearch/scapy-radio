options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: chan_select
  id: variable_qtgui_range
  parameters:
    label: chan_select
    start: '0'
    step: '1'
    stop: '40'
    value: '37'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label: Channel
    labels: '[i for i in range(0, 40)]'
    num_opts: '0'
    options: '[1000000 * (2402 + 2 * (i)) for i in range(0, 40)]'
    type: int
    value: '2402000000'
  states: {}
- name: gain_rec
  id: variable_qtgui_range
  parameters:
    label: gain_rec
    start: '0'
    step: '1'
    stop: '100'
    value: '80'
  states: {}
- name: gain_send
  id: variable_qtgui_range
  parameters:
    label: gain_send
    start: '0'
    step: '1'
    stop: '100'
    value: '80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: seuil
  id: variable_qtgui_range
  parameters:
    label: seuil
    start: '-100'
    step: '1'
    stop: '0'
    value: '-28'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: seuil
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: bt4le_packet_sink_0_0_0
  id: bt4le_packet_sink
  parameters:
    i_chan_nbr: chan_select
  states: {}
- name: bt4le_preamble_prefixer_0
  id: bt4le_preamble_prefixer
  parameters: {}
  states: {}
- name: bt4le_whitening_0
  id: bt4le_whitening
  parameters:
    chan_nbr: '37'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.030'
    mu: '0.5'
    omega_relative_limit: '0.200'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_1
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Scope Plot"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: RX/TX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    gain0: gain_send
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    clock_source0: external
    dev_addr: ''
    gain0: gain_rec
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', digital_gmsk_demod_0, '0']
- [bt4le_packet_sink_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [bt4le_packet_sink_0_0_0, out, network_socket_pdu_0, pdus]
- [bt4le_preamble_prefixer_0, out, bt4le_whitening_0, in]
- [bt4le_whitening_0, out, blocks_message_debug_0, print_pdu]
- [bt4le_whitening_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_gmsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gmsk_demod_0, '0', bt4le_packet_sink_0_0_0, '0']
- [digital_gmsk_mod_1, '0', uhd_usrp_sink_0, '0']
- [network_socket_pdu_1, pdus, bt4le_preamble_prefixer_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_1, '0']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
