options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: cut_freq
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-200e3'
    step: '200'
    stop: 200e3
    value: '-0e3'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: '100'
    value: '40'
  states: {}
- name: gain_send
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '20'
    stop: '100'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 800e3
  states: {}
- name: seuil
  id: variable_qtgui_range
  parameters:
    label: seuil
    start: '-100'
    step: '200'
    stop: '100'
    value: '-40'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,150e3,50e3,window.WIN_HAMMING)
  states: {}
- name: Zwave_packet_sink_0
  id: Zwave_packet_sink
  parameters: {}
  states: {}
- name: Zwave_preamble_0
  id: Zwave_preamble
  parameters: {}
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 2*(samp_rate)/(2*math.pi*20e3/8.0)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: seuil
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '20'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: (2*pi)*40e3
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '20'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-200e3'
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import sin, pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 868.40e6
    clock_rate: '0.0'
    dev_addr: ''
    gain0: gain_send
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq_offset+868.40e6+200e3
    clock_rate: '0.0'
    dev_addr: ''
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [Zwave_packet_sink_0, out, blocks_message_debug_0, print_pdu]
- [Zwave_packet_sink_0, out, network_socket_pdu_1, pdus]
- [Zwave_preamble_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vco_c_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vco_c_0, '0', uhd_usrp_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', Zwave_packet_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [network_socket_pdu_0, pdus, Zwave_preamble_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
